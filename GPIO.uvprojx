# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: BF7006BM48 Generic
  pack: BYD.BYDMicro_DFP.1.3.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x18000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: n2s_app +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\2_Src\Inc;C:\Keil_v5\ARM\PACK\BYD\BYDMicro_DFP\1.3.0\Device\Include\BF7006AMxx;C:\Keil_v5\ARM\PACK\BYD\BYDMicro_DFP\1.3.0\Device\Include\CMSIS
  memory RVCT4: ROM 0x5000 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./src/: main.c BF7006BMxx_it.c
  group Docs
    ./: README.txt
  group 2_Src
    ./2_Src/Src/: app_interface.c can_frame.c can_init.c eep.c
  group OSTK
    ./2_Src/Src/: OSTK.c
  group Data_Type
    ./2_Src/Inc/: DATA_TYPE.h
  group COMM
    ./2_Src/Src/: CAN_CFG.c CAN_TP.c
  group DCAN
    ./2_Src/Src/: DCAN.c
software components: CMSIS:CORE 5.0.1, Application:CAN 1.0.0, Application:LIN 1.0.3, CMSIS:BF7x06BM Header 1.0.0, Device:Peripheral Driver:ADC 1.0.2, Device:Peripheral Driver:CAN 1.0.2, Device:Peripheral Driver:EFlash 1.0.3, Device:Peripheral Driver:GPIO 1.0.3, Device:Peripheral Driver:PWM 1.0.4, Device:Peripheral Driver:RTC 1.0.2, Device:Peripheral Driver:SCI 1.0.2, Device:Peripheral Driver:Timer 1.0.2, Device:Peripheral Driver:Watch Dog Timer 1.0.2, Device:System Control 1.0.3, Startup:Startup 1.0.0
